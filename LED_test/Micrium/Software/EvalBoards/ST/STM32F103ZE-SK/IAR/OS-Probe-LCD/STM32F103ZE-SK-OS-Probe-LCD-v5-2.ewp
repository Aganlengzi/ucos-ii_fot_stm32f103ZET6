# IAR project STM32F103ZE-SK-OS-Probe-LCD-v5-2.ewp, settings and files
configuration Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\..\..\ucos-ii\ports\arm-cortex-m3\generic\iar; ..\..\..\..\..\ucos-ii\source; ..\..\..\..\..\uc-lib; ..\..\..\..\..\uc-cpu; ..\..\..\..\..\uc-cpu\ARM-Cortex-M3\IAR; ..\..\..\..\..\CPU\ST\STM32\inc; ..\..\..\..\..\CPU\ST\STM32\src; ..\BSP; ..\BSP\LCD; ..\BSP\SPI1; ..\..\..\..\..\uC-Probe\Target\Communication\Generic\RS-232\Source; ..\..\..\..\..\uC-Probe\Target\Communication\Generic\RS-232\Ports\ST\STM32; ..\..\..\..\..\uC-Probe\Target\Communication\Generic\Source; ..\..\..\..\..\uC-Probe\Target\Plugins\uCOS-II; ..\..\..\..\..\uC-Probe\Target\Demo\KSD\Source
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: STM32-SK-OS-Probe-LCD-v5.srec
  ILINK.IlinkOutputFile: STMF103ZE-SK-OS-Probe-LCD-v5-2.out
  ILINK.IlinkIcfFile: ..\BSP\STM32F103ZE_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ./: app.c app_cfg.h app_vect_v5.c includes.h os_cfg.h probe_com_cfg.h stm32f10x_conf.h
  group BSP/General
    ../BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c STM32F103ZE_FLASH.icf
  group BSP/LCD
    ../BSP/LCD/: arm_comm.h drv_glcd.c drv_glcd.h drv_glcd_cnfg.h glcd_ll.c glcd_ll.h Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group BSP/SPI1
    ../BSP/SPI1/: drv_spi1.c drv_spi1.h
  group CPU/inc
    ../../../../../CPU/ST/STM32/inc/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h
  group CPU/src
    ../../../../../CPU/ST/STM32/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uC/CPU
    ../../../../../uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
    ../../../../../uC-CPU/: cpu_def.h
  group uC/LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/OS-II/Port
    ../../../../../uCOS-II/Ports/arm-cortex-m3/Generic/IAR/: os_cpu.h
    ../../../../../uCOS-II/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC/OS-II/Source
    ../../../../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uC/Probe/Target/Communication/OS/uCOS-II
    ../../../../../uC-Probe/Target/Communication/Generic/OS/uCOS-II/: probe_com_os.c
  group uC/Probe/Target/Communication/RS-232/OS/uCOS-II
    ../../../../../uC-Probe/Target/Communication/Generic/RS-232/OS/uCOS-II/: probe_rs232_os.c
  group uC/Probe/Target/Communication/RS-232/Ports
    ../../../../../uC-Probe/Target/Communication/Generic/RS-232/Ports/ST/STM32/: probe_rs232c.c probe_rs232c.h
  group uC/Probe/Target/Communication/RS-232/Source
    ../../../../../uC-Probe/Target/Communication/Generic/RS-232/Source/: probe_rs232.c probe_rs232.h
  group uC/Probe/Target/Communication/Source
    ../../../../../uC-Probe/Target/Communication/Generic/Source/: probe_com.c probe_com.h
  group uC/Probe/Target/Demo/KSD/Source
    ../../../../../uC-Probe/Target/Demo/KSD/Source/: ksd.c ksd.h
  group uC/Probe/Target/Plugins/uCOS-II
    ../../../../../uC-Probe/Target/Plugins/uCOS-II/: os_probe.c os_probe.h
